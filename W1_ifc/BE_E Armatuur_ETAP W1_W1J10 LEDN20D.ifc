Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T08:33:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 08:33:05 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{F9E80368-E3FC-43AF-BB2D-33FAE0BFB1D0}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 08:33:05 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 08:33:05 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 08:33:05 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: W1J10 LEDN20D, Dummy:W1J10 LEDN20D:206009
In: Level 1
Type - PredefinedType: DIRECTIONSOURCE; Material: BERSnl_glas lamp, Aluminium cast
Type - Constraints - Default Elevation: 1219.2 mm; WT_H Behuizing: Standaard; WT_H Behuizing_medium en coarse: Standaard; WT_H Diameter: 370 mm; WT_H Offset lichtbron: 85 mm; WT_H Symbool straal: 190 mm
Type - Dimensions - BE_G Diameter: 380 mm; BE_G Hoogte: 95 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 20 W; BE_E Spanning: 230 V
Type - Graphics - WT_V Symbool plafond: Ronde armatuur; WT_V Symbool wand: TL-armatuur met 1 lamp
Type - Identity Data - BE_I Bestelcode: W1J10/LEDN20D; Manufacturer: ETAP; Model: W1; RS_C_drs_content_creator: © Witas; RS_C_drs_content_provider: Etap; RS_C_fabrikant_artikelcode: W1J10/LEDN20D; RS_C_fabrikant_bibliotheek_versie: 1; RS_C_fabrikant_jaartal: 2015; RS_C_IFC_versie: 2x3; RS_C_revit_versie: 2012; Type Comments: verlichtingsarmatuur; Type Name: W1J10 LEDN20D; URL: http://www.etaplighting.com/level2.aspx?seq=86&seqpicture=2227&name=Lighting&LangType=1033; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - BE_G Materiaal/Kleur: Aluminium cast; WT_V Materiaal_reflector: BERSnl_glas lamp
Type - Model Properties - WT_I Armatuurrendement: 1; WT_I IP klasse: IP20; WT_I Kleur: grijs; WT_I Lichtverdeling: zeer breedstalend; WT_I Maatschets catalogus: -; WT_I Maximale temperatuur: 850°C; WT_I Montage: opbouw; WT_I Optiek: diffusor; WT_I Type: individueel; WT_I UGR: <=25; WT_I Voorschakelapparaat: D; WT_I Vorm: rond
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP W1 - lichtbron: W1J10_LEDN20_D; WT_I Lamptype: Low PowerLed; WT_I LEDs_aantal: 1; WT_I Luminantie: 0; WT_I Vermogen lamp: 20 W
Type - Text - WT_I Revit handleiding: www.witas.be/nl/etap
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: W1J10 LEDN20D
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.170113 m2; Volume: 0.0107737 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-20 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 5
Other - Family: Dummy: W1J10 LEDN20D; Family and Type: Dummy: W1J10 LEDN20D; Schedule Level: Level: Level 1; Type: Dummy: W1J10 LEDN20D; Type Id: Dummy: W1J10 LEDN20D
Phasing - Phase Created: 469492
